# Keil uVision project AC_CR_RTX.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AC_CR_RTX
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __RTGT_UART
  c include: .\Project3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./Project2/: GLCD_Scroll.c GLCD_SPI_LPC1700.c Retarget.c Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_Scroll.h
    ./Project3/: delay.h ece_spi.h led.h MPU9250.h sensor_fusion.h timer.h type.h ece_spi.c led.c MPU9250.c sensor_fusion.c timer.c uart.c uart.h
    ./: lab4_main_pt1.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 1.0.0
